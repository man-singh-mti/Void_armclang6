# Keil uVision project Void.uvprojx, settings and files
target Void_REL (6240000::V6.24::ARMCLANG)
  device: STM32F722RETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x807FFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: void_mvp +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F722xx
  c include: Source/Core/Inc;Drivers/STM32F7xx_HAL_Driver/Inc;Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;Drivers/CMSIS/Device/ST/STM32F7xx/Include;Drivers/CMSIS/Include;Source/Device/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group MDK-ARM
    Drivers/: startup_stm32f722xx.s
  group Core
    Source/Core/Src/: main.c gpio.c adc.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Device
    Source/Device/Src/: vmt_command.c vmt_device.c vmt_string.c vmt_uart.c vmt_adc.c vmt_icm20948.c mti_imu.c mti_water.c vmt_flash.c vmt_flash_fifo.c mti_system.c mti_can.c vmt_i2c_async.c pca9534.c xm125_async.c xm125_profiles.c mti_void.c mti_radar.c
  group Drivers/STM32F7xx_HAL_Driver
    Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_can.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Drivers/CMSIS
    Source/Core/Src/: system_stm32f7xx.c
target Void_DBG (6240000::V6.24::ARMCLANG)
  device: STM32F722RETx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.1.1
  cpu: as above
  output: void_mvp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F722xx,DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
software components: CMSIS:CORE 6.2.0
